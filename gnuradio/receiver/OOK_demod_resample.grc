options:
  parameters:
    generate_options: qt_gui
    id: OOK_demod_resamp
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandpass_filter
  id: variable
  parameters:
    value: firdes.band_pass(1.0, samp_rate, 1, bandpass_width/2, bandpass_width)
  states: {}
- name: bandpass_width
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: cutoff_freq
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: filename
  id: variable
  parameters:
    comment: |-
      creates full path to backscatter recording
      and adds timestamp
    value: rootdir+record_file_path+str(datetime.fromtimestamp(time.time()).strftime('%Y_%m_%d_%H_%M_%S'))+".csv"
  states: {}
- name: freq
  id: variable
  parameters:
    value: 917E6
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '512000'
  states: {}
- name: lowpass_filter
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, cutoff_freq, transition_width, firdes.WIN_HAMMING, 6.76)
  states: {}
- name: record_file_path
  id: variable
  parameters:
    comment: set path to IQ recording directory
    value: '"\\Documents\\Reindeer\\Backscattering\\"'
  states: {}
- name: rootdir
  id: variable
  parameters:
    comment: defaults to your users home directory
    value: str(os.path.expanduser("~"))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: 20e3
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: filename
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\u0105791\Documents\Reindeer\Backscattering\backscatterdata_917MHz_20cm_13dBm
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '3E-6'
    init: '0'
    low: '1E-6'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: symbol_rate
    ted_gain: '1.0'
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: freq_xlating_fir_filter_lp
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    decim: decimation
    samp_rate: samp_rate
    taps: lowpass_filter
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: import_datetime
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_time
  id: import
  parameters:
    imports: import time
  states: {}
- name: qtgui_time_sink_x_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: symbol_sync
    size: '1000'
    srate: samp_rate/symbol_rate
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    gain0: '20'
    norm_gain0: 'False'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_squared_1, '0', blocks_threshold_ff_0, '0']
- [blocks_file_source_0, '0', freq_xlating_fir_filter_lp, '0']
- [blocks_float_to_char_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_threshold_ff_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_float_to_char_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0_1_0_0, '0']
- [freq_xlating_fir_filter_lp, '0', blocks_complex_to_mag_squared_1, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_lp, '0']

metadata:
  file_format: 1
