options:
  parameters:
    author: Bert Cox
    generate_options: qt_gui
    id: OOK_Xfilter_Name
    output_language: python
    title: OOK_Xfilter
  states: {}

blocks:
- name: bandpass_filter
  id: variable
  parameters:
    value: firdes.band_pass(1.0, samp_rate, 1, bandpass_width/2, bandpass_width)
  states: {}
- name: bandpass_width
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: cutoff_freq
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: filename
  id: variable
  parameters:
    comment: |-
      creates full path to backscatter recording
      and adds timestamp
    value: rootdir+record_file_path+str(datetime.fromtimestamp(time.time()).strftime('%Y_%m_%d_%H_%M_%S'))+".csv"
  states: {}
- name: freq
  id: variable
  parameters:
    value: 917E6
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '512000'
  states: {}
- name: lowpass_filter
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, cutoff_freq, transition_width, firdes.WIN_HAMMING, 6.76)
  states: {}
- name: moving_average
  id: variable_function_probe
  parameters:
    block_id: average_signal
    function_name: level
    poll_rate: '2000000'
    value: '0.01'
  states: {state: disabled}
- name: numbers
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1'
    step: '10'
    stop: '2000'
    value: '2000'
  states: {}
- name: record_file_path
  id: variable
  parameters:
    comment: set path to IQ recording directory
    value: '"\\Documents\\Reindeer\\Backscattering\\"'
  states: {}
- name: rootdir
  id: variable
  parameters:
    comment: defaults to your users home directory
    value: str(os.path.expanduser("~"))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: squelch_threshold
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-100'
    step: '1'
    stop: '0'
    value: '-40'
  states: {state: disabled}
- name: transition_width
  id: variable
  parameters:
    value: 20e3
  states: {}
- name: average_signal
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: filename
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_1
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: numbers
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '0.001'
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '100'
    max_iter: '100'
    scale: '1'
    type: float
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '3E-6'
    init: '0'
    low: '1E-6'
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '0101010101010101'
    tagname: preamble
    threshold: '0'
    type: byte
  states: {}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: freq+freq_offset
    freq_span: samp_rate/decimation
  states: {state: disabled}
- name: freq_xlating_fir_filter_lp
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    decim: decimation
    samp_rate: samp_rate
    taps: lowpass_filter
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: import_datetime
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_time
  id: import
  parameters:
    imports: import time
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: freq + freq_offset
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Voor"'
    size: '1024'
    srate: samp_rate/numbers
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Na"'
    size: '1024'
    srate: samp_rate/numbers
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    gain0: '20'
    norm_gain0: 'False'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_1, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_threshold_ff_0, '0']
- [blocks_float_to_char_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_float_to_char_1, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_float_to_char_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_float_to_char_1, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_moving_average_xx_0, '0', average_signal, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_threshold_ff_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_uchar_to_float_0, '0']
- [freq_xlating_fir_filter_lp, '0', blocks_complex_to_mag_squared_1, '0']
- [freq_xlating_fir_filter_lp, '0', fosphor_glfw_sink_c_0, '0']
- [freq_xlating_fir_filter_lp, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_lp, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
