options:
  parameters:
    author: Gilles Callebaut
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: 1E3
  states: {}
- name: channel_freq
  id: variable
  parameters:
    value: 910E6+521.7E3-1.44E3
  states: {}
- name: cutoff_freq
  id: variable
  parameters:
    value: baud_rate*5
  states: {}
- name: decimation
  id: variable
  parameters:
    value: int((samp_rate/baud_rate)//sps)
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: 20E3
  states: {}
- name: lowpass_filter
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, cutoff_freq, transition_width, window.WIN_HAMMING, 6.76)
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1E6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: 1E3
  states: {}
- name: tune_freq
  id: variable
  parameters:
    value: channel_freq - freq_offset
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: 80*sps
    threshold: '-10'
    type: float
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: int(10*samp_rate)
    threshold: '-10'
    type: complex
  states: {state: bypassed}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: decimation
    gain: '1'
    high_cutoff_freq: cutoff_freq+freq_offset
    low_cutoff_freq: freq_offset-cutoff_freq
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_short_0
  id: blocks_char_to_short
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Calle\OneDrive\Documenten\GitHub\EN-device-backscatter\gnuradio\receiver\rx_file.data
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: C:\Users\Calle\OneDrive\Documenten\output.txt
    type: short
  states: {state: disabled}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '110101010100100000001001000000001001101010111'
    tagname: preamble
    threshold: '0'
    type: byte
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import numpy as np


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, sps=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__( 
                  self,
                  name='OOK threshold',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.uint8, np.float32, np.float32, np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.avg = -1.0
              self.max = 0.0
              self.min = 1.0
              self.sps = sps

          def forecast(self, noutput_items, ninputs):
              # ensure 100 symbols before processing
              return [int(self.sps*100) for ii in range(ninputs)]


          def work(self, input_items, output_items):
              """example: multiply with constant"""

              if not len(input_items[0]) > 0:
                  return 0


              _max = np.max(input_items[0])
              _min = np.min(input_items[0])

              self.max += _max
              self.max /=2

              self.min += _min
              self.min /=2


              threshold = (self.max + self.min) * 0.2

              results = np.ones(len(input_items[0]), dtype=np.uint8)
              results[input_items[0] < threshold] = 0

              output_items[0][:] = results
              output_items[1][:] = self.max
              output_items[2][:] = self.min
              output_items[3][:] = threshold
              return len(output_items[0])
    sps: sps
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Symbol detector',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.set_history(2) # The comand set_history(x) appends the previous x-1 items to the input buffer (input_items), while the x'th item is the current value.

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              edges = np.diff(input_items[0])**2
              output_items[0][:] = edges

              return len(output_items[0])
  states: {state: disabled}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, sps=10, frame_size=10):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Gate till edge',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.sps = sps
              self.record_ongoing = False
              self.remainig_samples = 0
              self.trigger_detected = False

          def forecast(self, noutput_items, ninputs):
              # ensure 5 symbols before processing
              return [int(self.sps*5) for ii in range(ninputs)]

          def find_first(item, vec):
              for i in range(len(vec)):
                  if item == vec[i]:
                      return i
              return -1 

          def general_work(self, input_items, output_items):
              samples = input_items[0]

              output_samples = []

              # if 0->1 detected start new recording if not already done so, and output frame_size*self.sps
              if self.record_ongoing and self.remainig_samples > 0: #todo ensure the remaing samples ar larger then input_items
                  output_samples = samples[:self.remainig_samples]
                  self.remainig_samples = 0
                  self.record_ongoing = False

              if not self.record_ongoing:
                  # check if new positive edge is found
                  edge_idx = find_first(1, np.diff(samples)) + 1 # first where diff is 0->1, ie is 1 is positive edge and +1 bcs 1 starts at edge+1

                  if edge_idx > 0: # found an edge
                      self.record_ongoing = True

                      num_remaining_samples = len(samples) - edge_idx

                      if num_remaining_samples < frame_size*self.sps:
                          self.remainig_samples = frame_size*self.sps-num_remaining_samples
                          num_samples_to_process = frame_size*self.sps - self.remainig_samples
                      else:
                          num_samples_to_process = frame_size*self.sps
                          self.record_ongoing = False

                      output_samples = samples[edge_idx:edge_idx+num_samples_to_process]


              if len(output_items[0]) < len(output_samples): 
                  output_samples = output_samples[:len(output_items[0])]

              self.consume(0, len(samples))

              return len(output_samples)
    frame_size: '80'
    sps: sps
  states: {state: disabled}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.decim_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, decim_rate=10, sps=10):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.decim_block.__init__(
                  self,
                  name='Median',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.uint8],
                  decim = decim_rate)
              self.sps = sps
              self.set_relative_rate(1.0/decim_rate)
              self.decimation = decim_rate

          # def forecast(self, noutput_items, ninputs):
          #     # ensure 1 symbols before processing
          #     return [int(self.sps) for ii in range(ninputs)]

          def work(self, input_items, output_items):
              samples = input_items[0]

              N = len(samples)

              num_symbols = N//self.sps
              
              samples_consumed = samples[:num_symbols*self.sps]

              bits_per_symbol = np.split(samples_consumed, num_symbols)

              symbols = [np.median(bits_per_symb) for bits_per_symb in bits_per_symbol]

              output_items[0][:] = symbols

              # self.consume(0, len(samples_consumed))

              return len(output_items[0])
    decim_rate: sps
    sps: sps
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, samp_rate=1E6, sps=10):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.basic_block.__init__(\n            self,\n            name='OOK Demodulator',   # will show up in GRC\n            in_sig=[np.uint8],\n            out_sig=[np.uint8]\n        )\n\n        # amount of samples per symbol\n        self.sps = sps\n        self.threshold = samp_rate / sps\n        # amount of samples that can be wrong when counting the 1's and 0's\n        self.error_threshold = self.threshold // 4\n\n        self.packet = ''\n        self.count_1 = 0 # Counts consecutive 1's\n        self.count_0 = 0 # Counts consecutive 0's\n        self.sample_1_complete = False\n        self.sample_0_complete = False\n        self.first_trigger = False\n\n    def forecast(self, noutput_items, ninputs):\n        # ensure 10 symbols before processing\n        return [int(self.sps*10) for ii in range(ninputs)]\n\n    def general_work(self, input_items, output_items):\n        samples = input_items[0]\n\n        num_samples = len(samples)\n\n        samples = np.array(samples)\n\n        symbols = []\n\n        sample_idx = 0\n\n        if num_samples == 0:\n            return 0\n\n        # wait till first trigger occurs, and start symbol timing from that\n        if not self.first_trigger:\n            signal_detected = np.sum(np.diff(input_items[0]) == 1) # num positive edge triggers\n            if signal_detected:\n                sample_idx = np.where(np.diff(input_items[0]) == 1)[0][0]\n                if num_samples-sample_idx > self.sps:\n                    self.first_trigger = True\n\n        if not self.first_trigger:\n            num_remaining_symbols = (num_samples - sample_idx)//self.sps\n            print(num_remaining_symbols)\n            if num_remaining_symbols > 0:\n                # only process the remaining symbols and leave the rest for next block iteration\n                num_processed_samples = sample_idx+num_remaining_symbols*self.sps\n                # by not processing the last remaing bits, we essentially put the next timing trigger on the first bit in the next block iteration\n                samples_to_process = samples[sample_idx:num_remaining_symbols*self.sps]\n                bits_per_symbol = np.split(samples_to_process, num_remaining_symbols)\n                symbols = [np.median(s) for s in bits_per_symbol]\n\n                self.consume(0, num_processed_samples)\n                self.produce(0, len(symbols))\n                output_items[0][:len(symbols)] = symbols\n            else:\n                self.consume(0, 0)\n                self.produce(0, 0)\n\n        else:\n            self.consume(0, 0)\n\n        return len(symbols)\n\n\n    def count_samples(self, sample1, sample2):\n        if(sample1 == 1):\n            self.count_1 += 1\n            if(sample2 == 0):\n                self.sample_1_complete = True \n        elif(sample1 == 0):\n            self.count_0 += 1\n            if(sample2 == 1):\n                self.sample_0_complete = True \n\n    \n    def process_sample(self, bit, count):\n        if(count > self.threshold - self.error_threshold and count < self.threshold + self.error_threshold):\n            return [bit], False\n        elif count < (self.threshold - self.error_threshold):\n            # ignore \n             return None, True\n        else:\n            num_bits =  int(count//(self.threshold - self.threshold//10))\n            return [bit]*num_bits, False\n\n"
    samp_rate: samp_rate/decimation
    sps: sps
  states: {state: disabled}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: channel_freq
    freq_span: samp_rate/decimation
  states: {state: disabled}
- name: fosphor_glfw_sink_c_0_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: channel_freq
    freq_span: samp_rate/decimation
  states: {state: disabled}
- name: fosphor_glfw_sink_c_0_0_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: tune_freq
    freq_span: samp_rate
  states: {state: disabled}
- name: freq_xlating_fir_filter_lp
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ''
    decim: decimation
    samp_rate: samp_rate
    taps: lowpass_filter
    type: ccc
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: black
    color3: magenta
    ctrlpanel: 'True'
    label1: Power
    label2: High
    label3: Low
    label4: Threshold
    marker1: '0'
    marker2: '0'
    marker3: '0'
    marker4: '0'
    nconnections: '4'
    size: '1024'
    srate: baud_rate*sps
    style1: '0'
    style2: '0'
    style3: '0'
    style4: '0'
    type: float
    ymax: '0.0004'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"Na"'
    size: '1024'
    srate: baud_rate
    type: float
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: black
    ctrlpanel: 'True'
    label1: Power
    size: int(samp_rate)
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    label2: Symbol detected
    marker1: '6'
    name: '"RX magn"'
    nconnections: '3'
    size: int(samp_rate/decimation)
    srate: samp_rate/decimation
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"RX magn"'
    size: '1024'
    srate: (samp_rate/decimation)/sps
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: tune_freq
    fftsize: '1024'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: tune_freq
    dc_offs_enb0: auto
    gain0: rf_gain
    iq_imbal_enb0: auto
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_push_sink_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5558
    timeout: '100'
    type: float
  states: {state: disabled}

connections:
- [analog_pwr_squelch_xx_0, '0', blocks_float_to_char_0, '0']
- [analog_pwr_squelch_xx_0_0, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [band_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [band_pass_filter_0, '0', blocks_file_sink_0, '0']
- [band_pass_filter_0, '0', qtgui_const_sink_x_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [band_pass_filter_0, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_xx_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_1_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_char_to_float_1_1, '0', analog_pwr_squelch_xx_0, '0']
- [blocks_char_to_short_0, '0', blocks_file_sink_1, '0']
- [blocks_complex_to_mag_0, '0', epy_block_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_mag_squared_0, '0', epy_block_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', zeromq_push_sink_0_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_float_to_char_0, '0', epy_block_1_0_0, '0']
- [blocks_keep_one_in_n_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_multiply_xx_0_0, '0', qtgui_time_sink_x_1, '2']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_char_to_float_1, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_char_to_short_0, '0']
- [epy_block_0, '0', blocks_char_to_float_1_0, '0']
- [epy_block_0, '0', blocks_char_to_float_1_1, '0']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_0, '0', epy_block_1_0, '0']
- [epy_block_0, '0', epy_block_2, '0']
- [epy_block_0, '1', blocks_multiply_xx_0, '1']
- [epy_block_0, '1', blocks_multiply_xx_0_0, '1']
- [epy_block_0, '1', qtgui_time_sink_x_0, '1']
- [epy_block_0, '2', qtgui_time_sink_x_0, '2']
- [epy_block_0, '3', qtgui_time_sink_x_0, '3']
- [epy_block_1, '0', blocks_char_to_float_0, '0']
- [epy_block_1_0, '0', blocks_keep_one_in_n_0, '0']
- [epy_block_1_0, '0', epy_block_1_0_0, '0']
- [epy_block_1_0_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [epy_block_2, '0', digital_correlate_access_code_tag_xx_0, '0']
- [freq_xlating_fir_filter_lp, '0', blocks_complex_to_mag_0, '0']
- [freq_xlating_fir_filter_lp, '0', blocks_complex_to_mag_squared_0, '0']
- [freq_xlating_fir_filter_lp, '0', blocks_file_sink_0, '0']
- [freq_xlating_fir_filter_lp, '0', fosphor_glfw_sink_c_0, '0']
- [freq_xlating_fir_filter_lp, '0', fosphor_glfw_sink_c_0_0, '0']
- [freq_xlating_fir_filter_lp, '0', qtgui_const_sink_x_0, '0']
- [freq_xlating_fir_filter_lp, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_lp, '0', qtgui_time_sink_x_1, '0']
- [freq_xlating_fir_filter_lp, '0', qtgui_waterfall_sink_x_1, '0']
- [uhd_usrp_source_0, '0', analog_pwr_squelch_xx_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [uhd_usrp_source_0, '0', fosphor_glfw_sink_c_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_lp, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
