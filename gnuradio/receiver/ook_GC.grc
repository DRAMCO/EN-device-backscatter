options:
  parameters:
    author: Gilles Callebaut
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: 1E3
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: channel_freq - freq_offset
  states: {}
- name: channel_freq
  id: variable
  parameters:
    value: 910E6
  states: {}
- name: cutoff_freq
  id: variable
  parameters:
    value: 850e3
  states: {}
- name: fftsize
  id: variable
  parameters:
    value: '512'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: 1E6
  states: {}
- name: lowpass_filter
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, cutoff_freq, transition_width, window.WIN_HAMMING, 6.76)
  states: {}
- name: oversampled
  id: variable
  parameters:
    value: samp_rate/baud_rate
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4E6
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: int(baud_rate)
    threshold: '-16'
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: signal_size*5*oversampled
    type: float
  states: {}
- name: freq_xlating_fir_filter_lp
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    decim: '1'
    samp_rate: samp_rate
    taps: lowpass_filter
    type: ccc
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: ''
    name: '"Magnitude"'
    size: fftsize
    srate: samp_rate
    tr_level: '0.018'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '0.4'
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: fftsize
    name: '"Raw samples"'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: fftsize
    name: '"Post-filter"'
    showports: 'True'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    gain0: rf_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: zeromq_push_sink_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5558
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_complex_to_mag_0, '0', analog_pwr_squelch_xx_0, '0']
- [freq_xlating_fir_filter_lp, '0', blocks_complex_to_mag_0, '0']
- [freq_xlating_fir_filter_lp, '0', qtgui_waterfall_sink_x_0_1, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_lp, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
